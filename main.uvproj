# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c config.h lcd12864.c lcd12864.h temp.c temp.h XPT2046.c XPT2046.h O2.c O2.h ds1302.c ds1302.h index.c nRF.h
